## boards/shields/atari_joystick/Kconfig.defconfig
```kconfig
if SHIELD_ATARI_JOYSTICK

config ZMK_KEYBOARD_NAME
	default "Atari BT Stick"

endif
```
